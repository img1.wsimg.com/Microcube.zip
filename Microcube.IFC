Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: Microcube.IFC
Time: 2023-07-19T05:30:45
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 mm

# IfcBuildingElementProxy: 10082 - Slam Lock - Body_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 10082 - Slam Lock - Cam_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 10082 - Slam Lock - Inner_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: LS-01_Default
In: Default Storey
PredefinedType: ELEMENT; Material: AISI 1020 Steel, Cold Rolled

# IfcBuildingElementProxy: MSJ-01_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0
PSet_Mass_Property - Mass Measure: 219.401; Area Measure: 546145 m2; Volume Measure: 208538 m3

# IfcBuildingElementProxy: MSJ-05_Default
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: MSJ-06_Default (2)
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: MSJ-07_Default
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: MSJ-08_Default
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: MSJ-10_Default
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: MSJ-13_Default
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: MSJ-14_Default
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: MSJ-15_Default
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: cross recessed pan head screws gb_GB_CROSS_SCREWS_TYPE1 M4X5-5 H type-N (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: round head rivets gb_GB_CONNECTING_PIECE_RIVET_PCR 3X5 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0
